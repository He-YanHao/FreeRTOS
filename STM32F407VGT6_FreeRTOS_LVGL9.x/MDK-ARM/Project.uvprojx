# Keil uVision project Project.uvprojx, settings and files
target STM32F407VGT6 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\App\Inc;..\BSP\Inc;..\Core\Inc;..\Hardware\Inc;..\STM32F4xx_Driver\Inc;..\Middlewares\FreeRTOS;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM4F;..\Middlewares\LVGL\GUI;..\Middlewares\LVGL\GUI\lvgl;..\Middlewares\LVGL\GUI\lvgl\porting;..\Middlewares\LVGL\GUI\lvgl\src;..\Middlewares\LVGL\GUI_APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/Src/: Delay.c
  group BSP
    ../BSP/Src/: board.c board_Key.c board_LED.c board_BSP_USART.c
  group Core
    ../Core/Src/: main.c FreeRTOS_Task.c stm32f4xx_it.c system_stm32f4xx.c
    ../Core/Startup/: startup_stm32f40xx.s
  group FreeRTOS/Portable
    ../Middlewares/FreeRTOS/: FreeRTOSConfig.h
    ../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../Middlewares/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group FreeRTOS/Source
    ../Middlewares/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group STM32F4xx_Driver
    ../STM32F4xx_Driver/Src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group LVGL/porting
    ../Middlewares/LVGL/GUI/lvgl/porting/: lv_port_disp.c lv_port_fs_template.c lv_port_indev.c lv_port_lcd_stm32_template.c
  group LVGL/src
    ../Middlewares/LVGL/GUI/lvgl/src/: lv_init.c
  group LVGL/core
    ../Middlewares/LVGL/GUI/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
  group LVGL/display
    ../Middlewares/LVGL/GUI/lvgl/src/display/: lv_display.c
  group LVGL/draw
    ../Middlewares/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../Middlewares/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../Middlewares/LVGL/GUI/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../Middlewares/LVGL/GUI/lvgl/src/draw/convert/: lv_draw_buf_convert.c
  group LVGL/font
    ../Middlewares/LVGL/GUI/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group LVGL/indev
    ../Middlewares/LVGL/GUI/lvgl/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
  group LVGL/layouts
    ../Middlewares/LVGL/GUI/lvgl/src/layouts/: lv_layout.c
    ../Middlewares/LVGL/GUI/lvgl/src/layouts/flex/: lv_flex.c
    ../Middlewares/LVGL/GUI/lvgl/src/layouts/grid/: lv_grid.c
  group LVGL/libs
    ../Middlewares/LVGL/GUI/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
  group LVGL/misc
    ../Middlewares/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../Middlewares/LVGL/GUI/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../Middlewares/LVGL/GUI/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../Middlewares/LVGL/GUI/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
  group LVGL/osal
    ../Middlewares/LVGL/GUI/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
  group LVGL/stdlib
    ../Middlewares/LVGL/GUI/lvgl/src/stdlib/: lv_mem.c
    ../Middlewares/LVGL/GUI/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
  group LVGL/themes
    ../Middlewares/LVGL/GUI/lvgl/src/themes/: lv_theme.c
    ../Middlewares/LVGL/GUI/lvgl/src/themes/default/: lv_theme_default.c
    ../Middlewares/LVGL/GUI/lvgl/src/themes/mono/: lv_theme_mono.c
    ../Middlewares/LVGL/GUI/lvgl/src/themes/simple/: lv_theme_simple.c
  group LVGL/tick
    ../Middlewares/LVGL/GUI/lvgl/src/tick/: lv_tick.c
  group LVGL/widgets
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/span/: lv_span.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/animimage/: lv_animimage.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/arc/: lv_arc.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/bar/: lv_bar.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/button/: lv_button.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/canvas/: lv_canvas.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/chart/: lv_chart.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/image/: lv_image.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/label/: lv_label.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/led/: lv_led.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/line/: lv_line.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/list/: lv_list.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/lottie/: lv_lottie.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/menu/: lv_menu.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/roller/: lv_roller.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/scale/: lv_scale.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/slider/: lv_slider.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/spinner/: lv_spinner.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/switch/: lv_switch.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/table/: lv_table.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/tabview/: lv_tabview.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/textarea/: lv_textarea.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/tileview/: lv_tileview.c
    ../Middlewares/LVGL/GUI/lvgl/src/widgets/win/: lv_win.c
