# Keil uVision project Project.uvprojx, settings and files
target GD32F470 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.3.0
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c include: ..\App\Inc;..\BSP\Inc;..\Core\Inc;..\GD32F4xx_Driver\Include;..\GD32F4xx_Driver;..\Hardware\Inc;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\Keil\ARM_CM4F;..\Middlewares\FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/Src/: Delay.c usart.c
  group BSP
    ../BSP/Src/: BSP_LED.c BSP_KEY.c
  group Core
    ../Core/Src/: main.c gd32f4xx_it.c systick.c system_gd32f4xx.c
    ../../STM32F407VGT6_FreeRTOS/Core/Src/: FreeRTOS_Task.c
  group Startup
    ../Core/Startup/: startup_gd32f450_470.s
  group FreeRTOS/Portable
    ../Middlewares/FreeRTOS/: FreeRTOSConfig.h
    ../Middlewares/FreeRTOS/MemMang/: heap_4.c
    ../Middlewares/FreeRTOS/Keil/ARM_CM4F/: port.c
  group FreeRTOS/Source
    ../Middlewares/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group GD32F4xx_Driver
    ../GD32F4xx_Driver/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
